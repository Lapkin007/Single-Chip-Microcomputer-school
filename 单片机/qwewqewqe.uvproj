# Keil uVision project qwewqewqe.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91C140 Atmel
  cpu: IRAM(0xFC000000-0xFC00FFFF) CLOCK(40000000) CPUTYPE(ARM7TDMI)
  output: qwewqewqe
  c flags: Optim=1
  memory RVCT9: RAM 0xfc000000 size 0x10000
  group Source Group 1
    ./: Startup.s project
